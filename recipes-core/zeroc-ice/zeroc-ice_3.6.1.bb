ICE_VERSION = "3.6.1"

require zeroc-ice.inc

SRC_URI = "git://github.com/zeroc-ice/icee.git;protocol=http;branch=3.6"
SRCREV = "8c8ace8348ec39664faa127294bf151efb33d916"
